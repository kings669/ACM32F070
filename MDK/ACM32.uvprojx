# Keil uVision project ACM32.uvprojx, settings and files
target ACM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ACM32F070RBT7 Aisinochip
  pack: Aisinochip.ACM32F0X0.1.0.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ACM32
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Core_Drivers\CMSIS;..\Core_Drivers\Device;..\Core_Drivers\HAL_Driver\Inc;..\Core_Drivers\HAL_Driver\Src;..\User\BSP;..\Application
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CoreDriver/CMSIS
    ../Core_Drivers/CMSIS/: core_cm0.h
  group CoreDriver/Device
    ../Core_Drivers/Device/: ACM32F0x0.h Startup_ACM32F0x0.s System_ACM32F0x0.c System_ACM32F0x0.h
  group CoreDriver/HAL
    ../Core_Drivers/HAL_Driver/Src/: HAL_ADC.c HAL_CAN.c HAL_COMP.c HAL_CRC.c HAL_DIV.c HAL_DMA.c HAL_EXTI.c HAL_GPIO.c HAL_I2C.c HAL_IWDT.c HAL_LCD.c HAL_LPUART.c HAL_OPA.c HAL_RTC.c HAL_SPI.c HAL_TIMER.c HAL_TKEY.c HAL_UART.c HAL_UART_EX.c HAL_WDT.c HAL_EFLASH.c HAL_EFlash_EX.lib HAL_AES_20210422.lib HAL_DIV.lib HAL_HRNG_20210422.lib
  group User/MDK
    ./: main.c
  group User/BSP
    ../User/BSP/: led_usr.c ac_fifo.c buzzer.c lcd_GDC03828.c lcd_GDC04212.c lcd_YR1618A.c SHT30.c TKey.c rtc.c usart.c
  group Application
    ../Application/: LED_Task.c LCD_Task.c
software components: RTOS:kernel 3.1.5
